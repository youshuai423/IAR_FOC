# IAR project IMFOC.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV46F256xxx15 Freescale MKV46F256xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_MKV46F256VLL15=1; CLOCK_SETUP=5; ARM_MATH_CM4=1; DEMO=1; _DEBUG=1
  ICCARM.CCIncludePath2: Includes; sdk\cmsis\Include; sdk\devices; sdk\devices\MKV46F15\include; sdk\devices\MKV46F15\startup; sdk\devices\MKV46F15\startup\iar
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: IMFOC.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: C:\Users\yoush\Desktop\IAR_FOC\sdk\devices\MKV46F15\linker\iar\MKV46F256xxx15_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: imcontrol.c main.c ysADC.c ysPORT.c ysPWM.c
  group Includes
    Includes/: imcontrol.h main.h ysADC.h ysPORT.h ysPWM.h
  group sdk/cmsis/Include
    sdk/cmsis/Include/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0plus.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group sdk/devices
    sdk/devices/: fsl_device_registers.h startup.c startup.h
  group sdk/devices/MKV46F15/include
    sdk/devices/MKV46F15/include/: fsl_bitaccess.h MKV46F15.h MKV46F15_extension.h MKV46F15_features.h
  group sdk/devices/MKV46F15/startup
    sdk/devices/MKV46F15/startup/iar/: startup_MKV46F15.s
    sdk/devices/MKV46F15/startup/: system_MKV46F15.c system_MKV46F15.h
